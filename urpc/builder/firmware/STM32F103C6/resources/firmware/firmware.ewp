# IAR project firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F103x6 ST STM32F103x6
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER=1; USE_FULL_ASSERT=1; STM32F103x6; DEBUG
  ICCARM.CCIncludePath2: inc; ..\..\ST\stm32f1xx\STM32F1xx_HAL_Driver\Inc; ..\..\ST\stm32f1xx\STM32_USB_Device_Library\Core\Inc; ..\..\ST\stm32f1xx\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\ST\stm32f1xx\stm32f1xx-ll-driver\Drivers\STM32F1xx_LL_Driver\Include; ..\..\ST\stm32f1xx\stm32f1xx-ll-driver\Drivers\CMSIS\Include; ..\..\ST\stm32f1xx\stm32f1xx-ll-driver\Drivers\Device\ST\STM32F1xx\Include
  AARM.AUserIncludes: inc
  OBJCOPY.OOCOutputFile: firmware.srec
  ILINK.IlinkOutputFile: firmware.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  ILINK.IlinkIcfFile: debug.icf
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCDefines: USE_FULL_LL_DRIVER=1; STM32F103x6; NDEBUG
  group Code
    src/: algorithm.c commands.c flowparser.c handlers.c iobuffer.c main.c startup.c usb.c usbd_desc.c
  group FreeRTOS
    src/: croutine.c heap_1.c list.c port.c portasm.s queue.c tasks.c timers.c
    inc/: FreeRTOSConfig.h
  group Headers
    inc/: algorithm.h atomicrun.h callback.h commands.h flowparser.h handlers.h iobuffer.h macro.h settings.h startup.h systick.h config.h usb.h usbd_desc.h
  group Libraries
    ../../ST/stm32f1xx/stm32f1xx-ll-driver/Drivers/STM32F1xx_LL_Driver/ewarm/Exe/: driverlib.a
  group USB_Device_Library
    ../../ST/stm32f1xx/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c
    ../../ST/stm32f1xx/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c usbd_cdc_if.c
    ../../ST/stm32f1xx/STM32_USB_Device_Library/Core/Src/: usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_ioreq.c
