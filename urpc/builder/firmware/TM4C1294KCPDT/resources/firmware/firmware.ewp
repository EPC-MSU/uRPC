# IAR project firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C1294NCPDT TexasInstruments TM4C1294NCPDT
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; DEBUG; PART_TM4C1294KCPDT; DEPRECATED
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.1.2.111; inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: firmware.srec
  ILINK.IlinkOutputFile: xism_firmware.out
  ILINK.IlinkIcfFile: debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; NDEBUG; PART_TM4C1294KCPDT; DEPRECATED
  ICCARM.CCOptLevel: 3
  group Code/Application
    src/: handlers.c main.c startup.c
  group Code/FreeRTOS
    src/: croutine.c heap_1.c list.c port.c portasm.s queue.c tasks.c timers.c
  group Code/uRPC
    src/: algorithm.c commands.c flowparser.c iobuffer.c usb_composite.c
  group Headers
    inc/: algorithm.h atomicrun.h callback.h commands.h flowparser.h handlers.h iobuffer.h macro.h settings.h startup.h systick.h config.h usb_composite.h
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.2.111/driverlib/ewarm/Exe/: driverlib.a
    C:/ti/TivaWare_C_Series-2.1.2.111/usblib/ewarm/Exe/: usblib.a
