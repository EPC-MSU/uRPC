# IAR project firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR32F1x Milandr 1986BE9x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_MDR1986VE9x; USE_ASSERT_INFO=2; DEBUG
  ICCARM.CCIncludePath2: inc; ..\..\Milandr\k1986be92qi\emdr1986x-std-per-lib\MDR32F9Qx_StdPeriph_Driver\inc; ..\..\Milandr\k1986be92qi\emdr1986x-std-per-lib\MDR32F9Qx_StdPeriph_Driver\inc\USB_Library; ..\..\Milandr\k1986be92qi\emdr1986x-std-per-lib\Config; ..\..\Milandr\k1986be92qi\emdr1986x-std-per-lib\CMSIS\CM3\CoreSupport; ..\..\Milandr\k1986be92qi\emdr1986x-std-per-lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\startup; ..\..\Milandr\k1986be92qi\emdr1986x-std-per-lib\CMSIS\CM3\DeviceSupport\MDR32F9Qx\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: inc
  OBJCOPY.OOCOutputFile: firmware.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: debug.icf
  ILINK.IlinkProgramEntryLabel: main
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_MDR1986VE9x; USE_ASSERT_INFO=0; NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Code
    src/: algorithm.c commands.c flowparser.c handlers.c iobuffer.c main.c startup.c usb.c
  group FreeRTOS
    src/: croutine.c heap_1.c list.c port.c portasm.s queue.c tasks.c timers.c
    inc/: FreeRTOSConfig.h
  group Headers
    inc/: algorithm.h atomicrun.h callback.h commands.h flowparser.h handlers.h iobuffer.h macro.h settings.h startup.h systick.h config.h usb.h
  group Libraries
    ../../Milandr/k1986be92qi/emdr1986x-std-per-lib/MDR32F9Qx_StdPeriph_Driver/ewarm-cm3/Exe/: stdperiphlib-cm3.a
