# IAR project firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_FULL_ASSERT; DEBUG; STM32F429xx; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=1000; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1
  ICCARM.CCIncludePath2: ..\..\ST\stm32f4xx\stm32f4xx-ll-driver\Drivers\CMSIS\Include; ..\..\ST\stm32f4xx\stm32f4xx-ll-driver\Drivers\Device\ST\STM32F4xx\Include; ..\..\ST\stm32f4xx\stm32f4xx-ll-driver\Drivers\STM32F4xx_LL_Driver\Include; inc
  AARM.AUserIncludes: inc
  ILINK.IlinkOutputFile: firmware.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  ILINK.IlinkIcfFile: debug.icf
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCDefines: USE_FULL_LL_DRIVER=1; NDEBUG; STM32F429xx; HSE_VALUE=8000000; HSE_STARTUP_TIMEOUT=1000; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNAL_CLOCK_VALUE=12288000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=1; INSTRUCTION_CACHE_ENABLE=1; DATA_CACHE_ENABLE=1
  OBJCOPY.OOCOutputFile: firmware.srec
  group Code
    src/: algorithm.c commands.c flowparser.c handlers.c iobuffer.c main.c startup.c tty.c
  group FreeRTOS
    src/: croutine.c heap_1.c list.c port.c portasm.s queue.c tasks.c timers.c
  group Headers
    inc/: algorithm.h atomicrun.h commands.h flowparser.h handlers.h iobuffer.h macro.h settings.h startup.h tty.h
  group Libraries
    ../../ST/stm32f4xx/stm32f4xx-ll-driver/Drivers/STM32F4xx_LL_Driver/ewarm/Exe/: driverlib.a
