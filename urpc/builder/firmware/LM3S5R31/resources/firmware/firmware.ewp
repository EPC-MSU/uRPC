# IAR project firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3S5R31 TexasInstruments LM3S5R31
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; DEBUG; PART_LM3S5R31; DEPRECATED
  ICCARM.CCIncludePath2: C:\ti\StellarisWare; inc; src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: inc
  OBJCOPY.OOCOutputFile: firmware.srec
  ILINK.IlinkOutputFile: xism_firmware.out
  ILINK.IlinkIcfFile: debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; NDEBUG; PART_LM3S5R31; DEPRECATED
  ICCARM.CCIncludePath2: C:\ti\StellarisWare; inc
  ICCARM.CCOptLevel: 3
  group Code/Application
    src/: handlers.c main.c startup.c
  group Code/FreeRTOS
    src/: croutine.c heap_1.c list.c portasm.s queue.c tasks.c timers.c
  group Code/uRPC
    src/: algorithm.c commands.c flowparser.c iobuffer.c port.c usb_composite.c
  group Headers
    inc/: algorithm.h atomicrun.h callback.h commands.h flowparser.h FreeRTOSConfig.h handlers.h iobuffer.h macro.h portmacro.h settings.h startup.h systick.h timers.h usb_composite.h
  group Libraries
    C:/ti/StellarisWare/driverlib/ewarm-cm3/Exe/: driverlib-cm3.a
    C:/ti/StellarisWare/usblib/ewarm-cm3/Exe/: usblib-cm3.a
