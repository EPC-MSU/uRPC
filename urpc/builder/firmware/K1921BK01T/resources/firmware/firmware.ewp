# IAR project firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: K1921BK01T NIIET K1921BK01T
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_FULL_ASSERT=1; K1921VK01T; DEBUG
  ICCARM.CCIncludePath2: inc; ..\..\NIIET\k1921bk01t\niietcm4_usb\Libs\USB\Include; ..\..\NIIET\k1921bk01t\niietcm4_pd\Libs\Periph_Driver\Include; ..\..\NIIET\k1921bk01t\niietcm4_pd\Libs\CMSIS\Include; ..\..\NIIET\k1921bk01t\niietcm4_pd\Libs\Device\NIIET\K1921VK01T\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: inc
  OBJCOPY.OOCOutputFile: firmware.srec
  ILINK.IlinkOutputFile: firmware.out
  ILINK.IlinkIcfFile: debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: K1921VK01T; NDEBUG
  ICCARM.CCOptLevel: 3
  group Code
    src/: algorithm.c commands.c flowparser.c handlers.c iobuffer.c main.c startup.c usb.c
  group FreeRTOS
    src/: croutine.c heap_1.c list.c port.c portasm.s queue.c tasks.c timers.c
    inc/: FreeRTOSConfig.h
  group Headers
    inc/: algorithm.h atomicrun.h callback.h commands.h flowparser.h handlers.h iobuffer.h macro.h settings.h startup.h systick.h config.h usb.h
  group Libraries
    ../../NIIET/k1921bk01t/niietcm4_pd/Libs/Periph_Driver/ewarm/Exe/: driverlib.a
    ../../NIIET/k1921bk01t/niietcm4_usb/Libs/USB/ewarm/Exe/: usblib.a
