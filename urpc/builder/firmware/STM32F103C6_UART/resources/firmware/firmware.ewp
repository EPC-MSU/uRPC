# IAR project firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x6 ST STM32F103x6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER=1; USE_FULL_ASSERT=1; STM32F10X_LD; DEBUG
  ICCARM.CCIncludePath2: inc; ..\..\stm32f10x-stdperiph-driver\Libraries\STM32F10x_StdPeriph_Driver\Include; ..\..\stm32f10x-stdperiph-driver\Libraries\CMSIS\Include; ..\..\stm32f10x-stdperiph-driver\Libraries\Device\ST\STM32F10x\Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: firmware.srec
  ILINK.IlinkOutputFile: firmware.out
  ILINK.IlinkIcfFile: debug.icf
  ILINK.IlinkProgramEntryLabel: main
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MDR32F1x Milandr 1986BE9x
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER=1; STM32F10X_LD; NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group Code
    src/: algorithm.c callback.c commands.c flowparser.c handlers.c iobuffer.c main.c startup.c systick.c tty.c
  group Headers
    inc/: algorithm.h atomicrun.h callback.h commands.h flowparser.h handlers.h iobuffer.h macro.h settings.h startup.h systick.h tty.h
  group Libraries
    ../../stm32f10x-stdperiph-driver/Libraries/STM32F10x_StdPeriph_Driver/ewarm/Exe/: driverlib.a
