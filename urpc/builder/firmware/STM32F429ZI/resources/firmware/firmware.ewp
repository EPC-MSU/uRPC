# IAR project firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F429xx; USE_FULL_ASSERT; EPC_SIMPLIFIED_HAL_PCD
  ICCARM.CCIncludePath2: inc; ..\..\ST\stm32f4xx\STM32F4xx_HAL_Driver\Inc; ..\..\ST\stm32f4xx\STM32_USB_Device_Library\Core\Inc; ..\..\ST\stm32f4xx\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\ST\stm32f4xx\stm32f4xx-ll-driver\Drivers\CMSIS\Include; ..\..\ST\stm32f4xx\stm32f4xx-ll-driver\Drivers\Device\ST\STM32F4xx\Include; ..\..\ST\stm32f4xx\stm32f4xx-ll-driver\Drivers\STM32F4xx_LL_Driver\Include
  AARM.AUserIncludes: inc
  ILINK.IlinkOutputFile: firmware.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  ILINK.IlinkIcfFile: stm32f429xx_flash.icf
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32F429xx; EPC_SIMPLIFIED_HAL_PCD
  OBJCOPY.OOCOutputFile: firmware.srec
  group Code
    src/: algorithm.c commands.c flowparser.c handlers.c iobuffer.c main.c startup.c usb.c usbd_desc.c
  group FreeRTOS
    src/: croutine.c heap_1.c list.c port.c portasm.s queue.c tasks.c timers.c
  group Headers
    inc/: algorithm.h atomicrun.h commands.h flowparser.h handlers.h iobuffer.h macro.h settings.h startup.h config.h usb.h
    src/: usbd_desc.h
  group Libraries
    ../../ST/stm32f4xx/stm32f4xx-ll-driver/Drivers/STM32F4xx_LL_Driver/ewarm/Exe/: driverlib.a
  group USB_Device_Library
    ../../ST/stm32f4xx/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_ll_usb.c
    ../../ST/stm32f4xx/STM32_USB_Device_Library/Core/Src/: usb_device.c usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../../ST/stm32f4xx/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c usbd_cdc_if.c
