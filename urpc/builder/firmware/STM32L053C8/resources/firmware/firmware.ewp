# IAR project firmware.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L053x8 ST STM32L053x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER=1; USE_FULL_ASSERT=1; STM32L053xx; DEBUG
  ICCARM.CCIncludePath2: inc; ..\..\ST\stm32l0xx\STM32L0xx_HAL_Driver\Inc; ..\..\ST\stm32l0xx\STM32_USB_Device_Library\Core\Inc; ..\..\ST\stm32l0xx\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\ST\stm32l0xx\stm32l0xx-ll-driver\Drivers\STM32L0xx_LL_Driver\Include; ..\..\ST\stm32l0xx\stm32l0xx-ll-driver\Drivers\CMSIS\Include; ..\..\ST\stm32l0xx\stm32l0xx-ll-driver\Drivers\Device\ST\STM32L0xx\Include
  AARM.AUserIncludes: inc
  OBJCOPY.OOCOutputFile: firmware.srec
  ILINK.IlinkOutputFile: firmware.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  ILINK.IlinkIcfFile: debug.icf
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  ICCARM.CCDefines: USE_FULL_LL_DRIVER=1; STM32L053xx; NDEBUG
  group Code
    src/: algorithm.c commands.c flowparser.c handlers.c iobuffer.c main.c startup.c usb.c usbd_desc.c
  group FreeRTOS
    src/: croutine.c heap_1.c list.c port.c portasm.s queue.c tasks.c timers.c
    inc/: FreeRTOSConfig.h
  group Headers
    inc/: algorithm.h atomicrun.h commands.h flowparser.h handlers.h iobuffer.h macro.h settings.h startup.h usb.h config.h
    src/: usbd_desc.c
  group Libraries
    ../../ST/stm32l0xx/stm32l0xx-ll-driver/Drivers/STM32L0xx_LL_Driver/EWARM/Exe/: driverlib.a
  group USB_Device_Library
    ../../ST/stm32l0xx/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c
    ../../ST/stm32l0xx/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c usbd_cdc_if.c
    ../../ST/stm32l0xx/STM32_USB_Device_Library/Core/Src/: usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_ioreq.c
